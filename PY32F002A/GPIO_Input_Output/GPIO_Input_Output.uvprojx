# Keil uVision project GPIO_Input_Output.uvprojx, settings and files
target GPIO_Input_Output (6210000::V6.21::ARMCLANG)
  device: PY32F002Ax5 Puya
  pack: Puya.PY32F0xx_DFP.1.2.8
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00005000) IROM2(0x1FFF0E80,0x00000010) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: GPIO_Input_Output
  AfterMake: fromelf.exe --bin --output=.\Objects\@L.bin .\Objects\@L.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: PY32F002Ax5
  memory RVCT4: ROM 0x8000000 size 0x5000
  memory RVCT5: ROM 0x1fff0e80 size 0x10
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
