# Keil uVision project UART_Interrupt.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: PY32F002Ax5 Puya
  pack: Puya.PY32F0xx_DFP.1.2.8
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00005000) IROM2(0x1FFF0E80,0x00000010) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: UART_Interrupt +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: PY32F002Ax5
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT5: ROM 0x1fff0e80 size 0x10
  memory RVCT9: RAM 0x20000000 size 0x800
  group Source Group 1
    ./: main.c uart.h uart.c uart old code.txt gpio.h gpio.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
